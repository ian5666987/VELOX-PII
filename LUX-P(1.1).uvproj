# Keil uVision project LUX-P(1.1).uvproj, settings and files
target LUX-P Ver 1.1 (MCS-51)
  device: C8051F120 Silicon Laboratories, Inc.
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFFF) CLOCK(100000000) MDU_F120
  output: LUX-P(1.1)
  c flags: Optimize=9 SizeSpeed=1
  group Common Source Files
    ./: STARTUP.A51 L51_BANK.A51 luxp_ADCS.c luxp_add.c luxp_antenna.c luxp_check.c luxp_cqueue.c luxp_debugging.c luxp_extra.c luxp_function.c luxp_ground.c luxp_init.c luxp_interrupts.c luxp_ISIS.c luxp_main.c luxp_PWRS.c luxp_RTC.c luxp_RW.c luxp_schedule.c luxp_SD.c luxp_send.c luxp_storing.c luxp_task.c luxp_time.c
